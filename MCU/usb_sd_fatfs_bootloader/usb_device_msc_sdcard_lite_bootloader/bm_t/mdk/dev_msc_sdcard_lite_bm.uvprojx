# Keil uVision project dev_msc_sdcard_lite_bm.uvprojx, settings and files
target dev_msc_sdcard_lite_bm debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK64FN1M0VLL12 NXP
  pack: NXP.MK64F12_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: dev_msc_sdcard_lite_bm.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: _DEBUG=1, DEBUG, CPU_MK64FN1M0VLL12, USB_STACK_BM, FRDM_K64F, FREEDOM
  c misc: --library_interface=armcc --diag_suppress=1296,186
  c include: ..;../../../..;../../../../../../CMSIS/Include;../../../../../../middleware/usb;../../../../../../middleware/usb/osa;../../../../../../middleware/usb/include;../../../../../../middleware/usb/device;../../../../../../middleware/usb/device;../../../../../../middleware/usb/include;../../../../../../middleware/usb/osa;../../../../../../devices/MK64F12/drivers;../../../../../../middleware/sdmmc/port;../../../../../../devices/MK64F12/drivers;../../../../../../devices/MK64F12/drivers;../../../../../../devices/MK64F12/drivers;../../../../../../devices/MK64F12/utilities/str;../../../../../../devices/MK64F12/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/serial_manager;../../../../../../devices/MK64F12/drivers;../../../../../../components/lists;../../../../../../devices/MK64F12/drivers;../../../../../../devices/MK64F12/drivers;../../../../../../devices/MK64F12;../../../../../../devices/MK64F12/drivers;../../../../../../middleware/sdmmc/inc;../../../../../../middleware/sdmmc/src;..\..\..\..\..\..\middleware\fatfs\source\fsl_sd_disk;..\..\..\..\..\..\middleware\fatfs\source
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove --predefine="-D__stack_size__=0x1000" --predefine="-D__heap_size__=0x100"
  group sdmmc-port
    ../: fsl_sdmmc_host.c fsl_sdmmc_event.c fsl_sdmmc_event.h
  group doc
    ../: readme.txt
  group source
    ../: disk_sdcard.c disk_sdcard.h usb_device_descriptor.c usb_device_descriptor.h usb_device_ch9.c usb_device_ch9.h usb_device_msc.c usb_device_msc.h usb_device_msc_ufi.c usb_device_msc_ufi.h usb_device_config.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group usb-device-source-khci
    ../../../../../../middleware/usb/device/: usb_device_khci.c usb_device_khci.h
  group usb-include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group drivers
    ../../../../../../devices/MK64F12/drivers/: fsl_sdhc.c fsl_sdhc.h fsl_gpio.c fsl_gpio.h fsl_sysmpu.c fsl_sysmpu.h fsl_clock.c fsl_clock.h fsl_uart.c fsl_uart.h fsl_port.h fsl_smc.c fsl_smc.h fsl_common.c fsl_common.h fsl_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h
  group usb-device-include
    ../../../../../../middleware/usb/device/: usb_device.h
  group usb-device-source
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
  group sdmmc-inc
    ../../../../../../middleware/sdmmc/inc/: fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
  group sdmmc-src
    ../../../../../../middleware/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group utilities
    ../../../../../../devices/MK64F12/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MK64F12/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MK64F12/utilities/: fsl_assert.c
  group component-uart
    ../../../../../../components/uart/: uart.h uart_adapter.c
  group component-serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group device
    ../../../../../../devices/MK64F12/: fsl_device_registers.h MK64F12.h system_MK64F12.c system_MK64F12.h MK64F12_features.h
  group startup
    ../../../../../../devices/MK64F12/arm/: startup_MK64F12.s
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h
  group fatfs_src
    ../../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c
    ../../../../../../middleware/fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group fatfs_inc
    ../../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.h
    ../../../../../../middleware/fatfs/source/: diskio.h ff.h integer.h
  group osa
    ../../../../../../middleware/usb/osa/: usb_osa.h usb_osa_bm.c usb_osa_bm.h
  group update-bootloader
    ../: update_bootloader.c update_bootloader.h
target dev_msc_sdcard_lite_bm release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK64FN1M0VLL12 NXP
  pack: NXP.MK64F12_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: dev_msc_sdcard_lite_bm.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: _DEBUG=0, NDEBUG, CPU_MK64FN1M0VLL12, USB_STACK_BM, FRDM_K64F, FREEDOM
  c misc: --library_interface=armcc --diag_suppress=1296,186
  c include: ..;../../../..;../../../../../../CMSIS/Include;../../../../../../middleware/usb;../../../../../../middleware/usb/osa;../../../../../../middleware/usb/include;../../../../../../middleware/usb/device;../../../../../../middleware/usb/device;../../../../../../middleware/usb/include;../../../../../../middleware/usb/osa;../../../../../../devices/MK64F12/drivers;../../../../../../middleware/sdmmc/port;../../../../../../devices/MK64F12/drivers;../../../../../../devices/MK64F12/drivers;../../../../../../devices/MK64F12/drivers;../../../../../../devices/MK64F12/utilities/str;../../../../../../devices/MK64F12/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/serial_manager;../../../../../../devices/MK64F12/drivers;../../../../../../components/lists;../../../../../../devices/MK64F12/drivers;../../../../../../devices/MK64F12/drivers;../../../../../../devices/MK64F12;../../../../../../devices/MK64F12/drivers;../../../../../../middleware/sdmmc/inc;../../../../../../middleware/sdmmc/src;..\..\..\..\..\..\middleware\fatfs\source;..\..\..\..\..\..\middleware\fatfs\source\fsl_sd_disk
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: as above
